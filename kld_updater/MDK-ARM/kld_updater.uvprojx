# Keil uVision project kld_updater.uvprojx, settings and files
target N32L40x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L406RB Nationstech
  pack: Nationstech.N32L40x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x6000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kld_updater
  AfterMake: fromelf --bin --output=.\kld_updater.bin .\Objects\kld_updater.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L40X, USE_STDPERIPH_DRIVER
  c include: ..\..\firmware\CMSIS\core;..\..\firmware\CMSIS\device;..\..\firmware\n32l40x_std_periph_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x801d800 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32l40x.s
  group CMSIS
    ../../firmware/CMSIS/device/: system_n32l40x.c
  group FWLB
    ../../firmware/n32l40x_std_periph_driver/src/: misc.c n32l40x_adc.c n32l40x_exti.c n32l40x_flash.c n32l40x_gpio.c n32l40x_pwr.c n32l40x_rcc.c n32l40x_rtc.c n32l40x_tim.c n32l40x_usart.c
  group USER
    ../src/: iap.c main.c n32l40x_it.c systick.c
